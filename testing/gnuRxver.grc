options:
  parameters:
    author: Barry Duggan
    description: NB FM receiver
    generate_options: qt_gui
    id: NFM_rcv
    output_language: python
    title: NFM_rcv
  states: {}

blocks:
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '-3000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_BLACKMAN
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rxBaseband
  id: variable
  parameters:
    value: 437.8e6
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: txBaseband
  id: variable
  parameters:
    value: 145.83e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.00'
    value: '0.05'
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: (int)(samp_rate/rf_decim)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '500'
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: rxBaseband
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfrom skyfield.api import load, wgs84\nimport serial\nimport time\n\nclass rigControl:\n    def __init__(self,lat,lon,satNum):\n        self.ts = load.timescale()\n\n        self.gs = wgs84.latlon(lat,lon)\n\n        satellites = load.tle_file(\"/home/radsat-gs/Desktop/austinsWorkspace/ground_station/src/active.txt\")\n        print(\"Loaded %s satellites\" % len(satellites))\n\n        catalog = {sat.model.satnum: sat for sat in satellites}\n        self.satellite = catalog[satNum]\n        print(self.satellite)\n\n    def getAzEl(self):\n        dist = self.satellite - self.gs\n        position = dist.at((self.ts).now())\n\n        el, az, _ = position.altaz()\n\n        return az.degrees, el.degrees\n\n    def isPass(self):\n        _, el = self.getAzEl()\n\n        if el > 5:\n            return True\n        else:\n            return False\n\n    def getDoppler(self,UL_FREQ,DL_FREQ,updateFiles = True):\n        dt = 1/86400\n        t1 = (self.ts).now() - dt\n        t2 = (self.ts).now()\n        t3 = (self.ts).now() + dt\n\n        comp1 = self.satellite.at(t1) - self.gs.at(t1)\n        comp2 = self.satellite.at(t2) - self.gs.at(t2)\n        comp3 = self.satellite.at(t3) - self.gs.at(t3)\n\n        dists = [comp1.distance().m,comp2.distance().m,comp3.distance().m]\n        satRate = abs((np.gradient(dists))[2])\n\n        ul_doppler = satRate * UL_FREQ / 299792458\n        dl_doppler = satRate * DL_FREQ / 299792458\n \n        print(\"Sat Rate:\",satRate)\n\n        print('UL Doppler: {:.1f} Hz'.format(ul_doppler))\n        print('DL Doppler: {:.1f} Hz'.format(dl_doppler))\n\n        if comp3.distance().m <= comp1.distance().m: # Approaching\n            UL_FREQ_shifted = UL_FREQ - ul_doppler\n            DL_FREQ_shifted = DL_FREQ + dl_doppler\n            print(\"Approaching\")\n\n        elif comp3.distance().m > comp1.distance().m: # Leaving\n            UL_FREQ_shifted = UL_FREQ + ul_doppler\n            DL_FREQ_shifted = DL_FREQ - dl_doppler\n            print(\"Leaving\")        \n\n        if updateFiles:\n            timeTime = time.time()\n            with open(\"ul_doppler.txt\",\"w\") as ul, open(\"dl_doppler.txt\",\"w\") as dl:\n                ul.write(str(timeTime) + \" \" + str(ul_doppler))\n                dl.write(str(timeTime) + \" \" + str(dl_doppler))\n                print()\n\n\n        return UL_FREQ_shifted, DL_FREQ_shifted\n\n    def getPassTimes(self, year, month, day, el = 5):\n        start = self.ts.utc(year,month,day)\n        stop  = self.ts.utc(year,month,day + 1)\n\n        t,events = self.satellite.find_events(self.gs,start,stop,altitude_degrees = 5.0)\n        eventNames = 'rise above %s°' % el, 'culminate', 'set below 5°'\n        for ti, event in zip(t, events):\n            name = eventNames[event]\n            print(ti.utc_strftime('%Y %b %d %H:%M:%S'), name)\n\n        return t,events\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, upBaseFreq=100e6, dnBaseFreq=100e6, gsLat=52.144176, gsLon=-106.612910, noradId=25544):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Doppler Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        \n        self.uplinkFreq = upBaseFreq\n        self.dnlinkFreq = dnBaseFreq\n        self.controller = rigControl(gsLat, gsLon, noradId)\n        \n        # Register message ports\n        self.message_port_register_out(pmt.intern('uplk_freq_msg'))\n        self.message_port_register_out(pmt.intern('dnlk_freq_msg'))\n        self.message_port_register_out(pmt.intern('pass_msg'))\n        self.message_port_register_in(pmt.intern('update_msg'))\n        self.set_msg_handler(pmt.intern('update_msg'), self.sendInfo)\n        \n    def sendInfo(self, msg):\n        upFreq, dnFreq = self.controller.getDoppler(self.uplinkFreq, self.dnlinkFreq)\n        isInPass = self.controller.isPass()\n        self.message_port_pub(pmt.intern('uplk_freq_msg'), pmt.cons(pmt.intern('value'),    pmt.to_pmt(upFreq)))\n        self.message_port_pub(pmt.intern('dnlk_freq_msg'), pmt.cons(pmt.intern('value'),    pmt.to_pmt(dnFreq)))\n        self.message_port_pub(pmt.intern('pass_msg'),      pmt.cons(pmt.intern('pass_msg'), pmt.to_pmt(isInPass)))\n        \n    def stop(self):\n        return True\n\n"
    dnBaseFreq: rxBaseband
    gsLat: '52.144176'
    gsLon: '-106.61291'
    noradId: '25544'
    upBaseFreq: txBaseband
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: rf_decim
    taps: channel_filter
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rxBaseband
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: rxGain
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, update_msg]
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [epy_block_0, dnlk_freq_msg, blocks_msgpair_to_var_1, inpair]
- [fft_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
