options:
  parameters:
    author: Crawford
    generate_options: hb
    id: FM_Modulator_rev1
    output_language: python
    title: FM_Modulator_rev1
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: centerFrequency
  id: variable
  parameters:
    value: frequencyDeviation * 8
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: samplesPerSymbol * baudRate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: centerFrequency + frequencyDeviation
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: centerFrequency - frequencyDeviation
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: baudRate
  id: parameter
  parameters:
    label: baudRate
    value: '9600'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samplesPerSymbol
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: exampleUnpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: frequencyDeviation
  id: parameter
  parameters:
    label: frequencyDeviation
    value: 4.8E3
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: FSK Mod
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: File Bin
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Input File
    type: byte
  states: {}
- name: samplesPerSymbol
  id: parameter
  parameters:
    label: samplesPerSymbol
    value: '80'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [exampleUnpack, '0', blocks_repeat_0, '0']
- [pad_source_0, '0', exampleUnpack, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
