options:
  parameters:
    author: Crawford
    generate_options: qt_gui
    id: FSK_testing
    output_language: python
    title: FSK_testing
  states: {}

blocks:
- name: TxFreq
  id: variable
  parameters:
    value: 145.4E6
  states: {}
- name: baudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: centerFrequency
  id: variable
  parameters:
    value: frequencyDeviation * 8
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: delay
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: 8*32
    value: '0'
  states: {}
- name: frequencyDeviation
  id: variable
  parameters:
    value: baudRate/2
  states: {}
- name: lowPassCutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: low pass filter cuttof
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '100'
    stop: sampleRate /2 -100
    value: frequencyDeviation*2+600
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: rfGain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: samplesPerSymbol * baudRate
  states: {}
- name: samplesPerSymbol
  id: variable
  parameters:
    value: '80'
  states: {}
- name: FM_Demodulator_rev1_0
  id: FM_Demodulator_rev1
  parameters:
    baudRate: baudRate
    frequencyDeviation: frequencyDeviation
    lowPassCutoff: lowPassCutoff
    samplesPerSymbol: samplesPerSymbol
  states: {}
- name: FM_Modulator_rev1_0
  id: FM_Modulator_rev1
  parameters:
    baudRate: baudRate
    frequencyDeviation: frequencyDeviation
    samplesPerSymbol: samplesPerSymbol
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: samplesPerSymbol
    taps: '1'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '1'
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: centerFrequency
    decim: '1'
    samp_rate: sampleRate
    taps: '1'
    type: fcc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"Pre Demod"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: '"post low pass"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Post-Mod
    label2: FIle Binary
    name: '"Modulated Carrier"'
    nconnections: '2'
    size: 8*samplesPerSymbol
    srate: sampleRate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    label1: Demod Tx
    label2: Input Tx
    name: '"Tx vs Rx"'
    nconnections: '2'
    size: 8*32
    srate: sampleRate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: TxFreq
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sampleRate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:11111
    timeout: '100'
    type: byte
  states: {}

connections:
- [FM_Demodulator_rev1_0, '0', qtgui_time_sink_x_1, '0']
- [FM_Demodulator_rev1_0, '1', qtgui_sink_x_0_0, '0']
- [FM_Modulator_rev1_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [FM_Modulator_rev1_0, '0', qtgui_time_sink_x_0, '0']
- [FM_Modulator_rev1_0, '1', fir_filter_xxx_0_0, '0']
- [FM_Modulator_rev1_0, '1', qtgui_time_sink_x_0, '1']
- [analog_random_source_x_0, '0', FM_Modulator_rev1_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_delay_0, '0', blocks_add_const_vxx_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0_0_0, '0', FM_Demodulator_rev1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', FM_Demodulator_rev1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', fir_filter_xxx_0_0_0, '0']
- [zeromq_sub_source_0, '0', FM_Modulator_rev1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
