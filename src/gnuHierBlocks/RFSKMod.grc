options:
  parameters:
    author: Crawford
    category: '[RADSAT-SK]'
    generate_options: hb
    hier_block_src_path: '~/.grc_gnuradio:'
    id: FSKMod
    output_language: python
    title: SDK Mod
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lowPassFilterFaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: frequencyDeviation*6
    gain: '1.0'
    samp_rate: sampleRate
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: samplesPerSymbol * baudRate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * math.pi * ( frequencyDeviation  / sampleRate )
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: centerFrequency + frequencyDeviation
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: centerFrequency - frequencyDeviation
    offset: '0'
    phase: '0'
    samp_rate: sampleRate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: baudRate
  id: parameter
  parameters:
    label: baudRate
    type: intx
    value: '9600'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samplesPerSymbol
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    do_unpack: 'False'
    samples_per_symbol: samplesPerSymbol
    sensitivity: 2 * pi * ( frequencyDeviation  / sampleRate )
  states: {}
- name: exampleUnpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: centerFrequency
    decim: '1'
    samp_rate: sampleRate
    taps: lowPassFilterFaps
    type: fcc
  states: {state: disabled}
- name: frequencyDeviation
  id: parameter
  parameters:
    label: frequencyDeviation
    type: eng_float
    value: '3500'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11500'
    decim: '1'
    gain: '1'
    samp_rate: sampleRate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: FSK Mod
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: File Bin
    optional: 'True'
    type: float
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Input File
    type: byte
  states: {}
- name: samplesPerSymbol
  id: parameter
  parameters:
    label: samplesPerSymbol
    type: intx
    value: '60'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_1, '1']
- [analog_frequency_modulator_fc_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_sub_xx_1, '0', analog_frequency_modulator_fc_0, '0']
- [digital_gfsk_mod_0, '0', pad_sink_0, '0']
- [exampleUnpack, '0', blocks_repeat_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', pad_sink_0, '0']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_gfsk_mod_0, '0']
- [pad_source_0, '0', exampleUnpack, '0']

metadata:
  file_format: 1
