options:
  parameters:
    author: Austin
    category: '[RADSAT-SK]'
    generate_options: hb
    id: GMSK_Demodulator
    output_language: python
    title: GMSK Demodulator
  states: {}

blocks:
- name: frequencyDeviation
  id: variable
  parameters:
    value: sampleRate//2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sampleRate/(2*math.pi*frequencyDeviation)
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samplesPerSymbol
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: error
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: bin out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sampleRate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '9600'
  states: {}
- name: samplesPerSymbol
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '30'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', pad_sink_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '1', pad_sink_0_0_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
