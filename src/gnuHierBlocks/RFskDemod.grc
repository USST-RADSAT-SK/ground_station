options:
  parameters:
    author: Crawford
    category: '[RADSAT-SK]'
    generate_options: hb
    hier_block_src_path: ~/.grc_gnuradio/
    id: fskDemod
    output_language: python
    title: FSK Demod
  states: {}

blocks:
- name: centerFrequency
  id: variable
  parameters:
    value: frequencyDeviation * 8
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: samplesPerSymbol * baudRate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (sampleRate/(2*math.pi*frequencyDeviation))
  states: {}
- name: baudRate
  id: parameter
  parameters:
    label: Baud Rate
    type: intx
    value: '9600'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samplesPerSymbol
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: frequencyDeviation
  id: parameter
  parameters:
    label: Frequency Deviation
    type: eng_float
    value: 4.8E3
  states: {}
- name: lowPassCutoff
  id: parameter
  parameters:
    label: Low Pass Cutoff Freq
    type: eng_float
    value: '10200'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lowPassCutoff
    decim: '1'
    gain: '1'
    samp_rate: sampleRate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: FSK Demod
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Post Low-Pass
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: FSK Mod
    type: complex
  states: {}
- name: samplesPerSymbol
  id: parameter
  parameters:
    label: Samples/Symbol
    type: intx
    value: '30'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_char_to_float_1, '0', pad_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
