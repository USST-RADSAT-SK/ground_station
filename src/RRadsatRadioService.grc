options:
  parameters:
    author: Crawford
    generate_options: qt_gui
    hier_block_src_path: './gnuHierBlocks:'
    id: radsatRadioService
    output_language: python
    run_command: gnome-terminal -- bash -c "{python} -u {filename}; echo type enter to exit; read"
    title: Radsat Radio Service
  states: {}

blocks:
- name: bufMax
  id: variable
  parameters:
    value: 256*8*2+64
  states: {}
- name: rxBaseband
  id: variable
  parameters:
    value: 435.4e6
  states: {}
- name: rxBaudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rxCorrection
  id: variable
  parameters:
    value: '-1000'
  states: {}
- name: rxFrequencyDeviation
  id: variable
  parameters:
    value: rxBaudRate // 4
  states: {}
- name: rxFrequencyOffset
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rxLowPassCutoff
  id: variable
  parameters:
    value: rxBaudRate+2000
  states: {}
- name: rxLowPassFilterTap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: rxLowPassCutoff
    gain: '1.0'
    samp_rate: rxSampleRate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: rxSampleRate
  id: variable
  parameters:
    value: rxSamplesPerSymbol * rxBaudRate
  states: {}
- name: rxSamplesPerSymbol
  id: variable
  parameters:
    value: '30'
  states: {}
- name: txBaseband
  id: variable
  parameters:
    value: 145.83E6
  states: {}
- name: txBaudRate
  id: variable
  parameters:
    value: rxBaudRate
  states: {}
- name: txCorrection
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txFrequencyDeviation
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: txFrequencyOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txGain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: txSampleRate
  id: variable
  parameters:
    value: txSamplesPerSymbol * txBaudRate
  states: {}
- name: txSamplesPerSymbol
  id: variable
  parameters:
    value: '60'
  states: {}
- name: FM_Modulator_rev1_0
  id: FM_Modulator_rev1
  parameters:
    baudRate: txBaudRate
    frequencyDeviation: txFrequencyDeviation
    samplesPerSymbol: txSamplesPerSymbol
  states: {}
- name: GMSK_Demodulator_0
  id: GMSK_Demodulator
  parameters:
    sampleRate: rxSampleRate
    samplesPerSymbol: rxSamplesPerSymbol
  states: {state: disabled}
- name: TRXVU_AX25_Deframer_0
  id: TRXVU_AX25_Deframer
  parameters: {}
  states: {state: disabled}
- name: TRXVU_AX_25_Framer_0
  id: TRXVU_AX_25_Framer
  parameters:
    destinationCallsign: RADSAT
    destinationSsid: '1'
    maxoutbuf: bufMax
    sourceCallsign: RADSAT
    sourceSsid: '2'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-1'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/Desktop/ground_station/testing/recordings/07-24-2022_b210_RADSAT-SK x20_trans
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: time
    type: string
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: txSampleRate
    fc: txBaseband
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"Pre Demod"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: rxSampleRate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 8*25*txSamplesPerSymbol
    srate: txSampleRate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"pkt_length"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    legend: 'False'
    size: 8*25*txSamplesPerSymbol
    srate: txSampleRate
    tr_tag: '"pkt_length"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: txBaseband
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: txGain
    samp_rate: txSampleRate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rxBaseband + rxFrequencyOffset
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: rxGain
    samp_rate: rxSampleRate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: xlatingFIRfilter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rxCorrection - rxFrequencyOffset
    decim: '1'
    samp_rate: rxSampleRate
    taps: rxLowPassFilterTap
    type: ccc
  states: {state: disabled}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:15531
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:15531
    timeout: '100'
  states: {state: disabled}
- name: zeromq_rep_msg_sink_0
  id: zeromq_rep_msg_sink
  parameters:
    address: tcp://127.0.0.1:15531
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:15530
    bind: 'True'
    timeout: '100'
  states: {state: disabled}

connections:
- [FM_Modulator_rev1_0, '0', qtgui_sink_x_0, '0']
- [FM_Modulator_rev1_0, '0', qtgui_time_sink_x_0, '0']
- [FM_Modulator_rev1_0, '0', qtgui_time_sink_x_0_1, '0']
- [FM_Modulator_rev1_0, '0', uhd_usrp_sink_0, '0']
- [GMSK_Demodulator_0, '2', TRXVU_AX25_Deframer_0, '0']
- [TRXVU_AX25_Deframer_0, msg_out, blocks_message_debug_0_0, print]
- [TRXVU_AX25_Deframer_0, msg_out, zeromq_pub_msg_sink_1, in]
- [TRXVU_AX25_Deframer_0, msg_out, zeromq_push_msg_sink_0, in]
- [TRXVU_AX25_Deframer_0, msg_out, zeromq_rep_msg_sink_0, in]
- [TRXVU_AX_25_Framer_0, '0', FM_Modulator_rev1_0, '0']
- [TRXVU_AX_25_Framer_0, '0', TRXVU_AX25_Deframer_0, '0']
- [analog_agc2_xx_0, '0', GMSK_Demodulator_0, '0']
- [blocks_file_source_1, '0', xlatingFIRfilter, '0']
- [qtgui_edit_box_msg_0, msg, TRXVU_AX_25_Framer_0, Info in]
- [uhd_usrp_source_0, '0', xlatingFIRfilter, '0']
- [xlatingFIRfilter, '0', analog_agc2_xx_0, '0']
- [xlatingFIRfilter, '0', qtgui_sink_x_1, '0']
- [zeromq_sub_msg_source_0, out, TRXVU_AX_25_Framer_0, Info in]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
