options:
  parameters:
    author: Crawford
    comment: |-
      Keep terminal open when closing the script
      gnome-terminal -- bash -c "{python} -u {filename}; echo Press Enter to close the terminal; read"

      Close terminal when closing the script
      gnome-terminal -- bash -c "{python} -u {filename};"
    generate_options: qt_gui
    hier_block_src_path: './gnuHierBlocks:'
    id: RRadsatRadioService
    output_language: python
    run_command: gnome-terminal -- bash -c "{python} -u {filename}; echo Press Enter to close the terminal; read"
    title: Radsat Radio Service
  states: {}

blocks:
- name: radsatCallsign
  id: variable
  parameters:
    value: '"RADSAT"'
  states: {}
- name: rxBaseband
  id: variable
  parameters:
    value: 435.4e6
  states: {}
- name: rxBaudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rxCorrection
  id: variable
  parameters:
    value: '-1000'
  states: {}
- name: rxFrequencyDeviation
  id: variable
  parameters:
    value: rxBaudRate // 4
  states: {}
- name: rxFrequencyOffset
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,0,1,1
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rxLowPassCutoff
  id: variable
  parameters:
    value: rxBaudRate+2000
  states: {}
- name: rxLowPassFilterTap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: rxLowPassCutoff
    gain: '1.0'
    samp_rate: rxSampleRate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: rxOverSample
  id: variable
  parameters:
    value: ceil(200000 / rxSampleRate)
  states: {}
- name: rxSampleRate
  id: variable
  parameters:
    value: rxSamplesPerSymbol * rxBaudRate
  states: {}
- name: rxSamplesPerSymbol
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sendFlags
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Send Inter-frame Flags
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: txBaseband
  id: variable
  parameters:
    value: 145.83E6
  states: {}
- name: txBaudRate
  id: variable
  parameters:
    value: rxBaudRate
  states: {}
- name: txCorrection
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txFrequencyDeviation
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: txFrequencyOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: txSampleRate
  id: variable
  parameters:
    value: txSamplesPerSymbol * txBaudRate
  states: {}
- name: txSamplesPerSymbol
  id: variable
  parameters:
    value: '120'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-1'
    gain: '1.0'
    max_gain: '65536'
    maxoutbuf: '1024'
    reference: '0.5'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/Desktop/ground_station/testing/recordings/07-24-2022_b210_RADSAT-SK x20_trans
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: fskMod_0
  id: fskMod
  parameters:
    baudRate: '9600'
    frequencyDeviation: '3500'
    maxoutbuf: '100'
    samplesPerSymbol: txSamplesPerSymbol
  states: {}
- name: gmskDemod_0
  id: gmskDemod
  parameters:
    sampleRate: rxSampleRate
    samplesPerSymbol: rxSamplesPerSymbol
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, ceil
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rxSampleRate
    color1: '"dark green"'
    color2: '"dark blue"'
    fc: rxBaseband
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1:1,0,1,1
    label1: Post Filtering
    label2: Pre Filtering
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.016'
    width1: '2'
    width2: '2'
    ymax: '1'
    ymin: '-250'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: txSampleRate
    fc: txBaseband
    fftsize: '1024'
    gui_hint: tabs@0:3,0,1,1
    name: '"Pre Demod"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: rxSampleRate
    fc: rxBaseband
    fftsize: '1024'
    gui_hint: tabs@1:2,0,1,1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    gui_hint: tabs@0:4,0,1,1
    legend: 'False'
    size: 8*32
    srate: txSampleRate
    tr_tag: '"pkt_length"'
    type: float
    update_time: '0.016'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Tx Tab
    label1: Rx Tab
    num_tabs: '2'
  states: {}
- name: trxvuAx25Deframer_0
  id: trxvuAx25Deframer
  parameters: {}
  states: {}
- name: trxvuAx25Framer_0
  id: trxvuAx25Framer
  parameters:
    EnableInterFrameFill: sendFlags
    SamplesPerSymbol: txSamplesPerSymbol
    destinationCallsign: radsatCallsign
    destinationSsid: '1'
    maxoutbuf: '8192'
    sourceCallsign: radsatCallsign
    sourceSsid: '10'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: txBaseband
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: txGain
    len_tag_name: '"tx_pkt_len"'
    maxoutbuf: '255'
    samp_rate: txSampleRate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rxBaseband + rxFrequencyOffset*0 + rxCorrection
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: rxGain
    samp_rate: rxSampleRate*rxOverSample
    sync: sync
    type: fc32
  states: {}
- name: xlatingFIRfilter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '- rxFrequencyOffset*0'
    decim: rxOverSample
    samp_rate: rxSampleRate
    taps: rxLowPassFilterTap
    type: ccc
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:15531
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:15530
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [analog_agc2_xx_0, '0', gmskDemod_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_file_source_1, '0', xlatingFIRfilter, '0']
- [fskMod_0, '0', qtgui_sink_x_0, '0']
- [fskMod_0, '0', uhd_usrp_sink_0, '0']
- [gmskDemod_0, '2', trxvuAx25Deframer_0, '0']
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [qtgui_freq_sink_x_0, freq, xlatingFIRfilter, freq]
- [trxvuAx25Deframer_0, msg_out, zeromq_push_msg_sink_0, in]
- [trxvuAx25Framer_0, '0', blocks_char_to_float_0, '0']
- [trxvuAx25Framer_0, '0', fskMod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', xlatingFIRfilter, '0']
- [xlatingFIRfilter, '0', analog_agc2_xx_0, '0']
- [xlatingFIRfilter, '0', qtgui_freq_sink_x_0, '0']
- [xlatingFIRfilter, '0', qtgui_sink_x_1, '0']
- [zeromq_sub_msg_source_0, out, trxvuAx25Framer_0, Info in]

metadata:
  file_format: 1
