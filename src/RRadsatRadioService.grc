options:
  parameters:
    author: Crawford
    comment: |-
      Keep terminal open when closing the script
      gnome-terminal -- bash -c "{python} -u {filename}; echo Press Enter to close the terminal; read"

      Close terminal when closing the script
      gnome-terminal -- bash -c "{python} -u {filename};"
    generate_options: qt_gui
    hier_block_src_path: './gnuHierBlocks:'
    id: RRadsatRadioService
    output_language: python
    title: Radsat Radio Service
  states: {}

blocks:
- name: qtgui_dialgauge_0
  id: qtgui_dialgauge
  parameters:
    label: Transmiter Doppler
    maximum: txBaseband+10000
    minimum: txBaseband-10000
    showValue: 'True'
    type: real
    value: txBaseband
  states: {state: disabled}
- name: qtgui_dialgauge_0_0
  id: qtgui_dialgauge
  parameters:
    label: Reciever Doppler
    maximum: rxBaseband+10000
    minimum: rxBaseband-10000
    showValue: 'True'
    type: real
    value: rxBaseband
  states: {state: disabled}
- name: radsatCallsign
  id: variable
  parameters:
    value: '"RADSAT"'
  states: {}
- name: rxBaseband
  id: variable
  parameters:
    value: 435.4e6
  states: {}
- name: rxBaudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rxCorrection
  id: variable
  parameters:
    value: '-1000'
  states: {}
- name: rxFrequencyDeviation
  id: variable
  parameters:
    value: rxBaudRate // 4
  states: {}
- name: rxFrequencyOffset
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,0,1,1
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: rxLowPassCutoff
  id: variable
  parameters:
    value: rxBaudRate+2000
  states: {}
- name: rxLowPassFilterTap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: rxLowPassCutoff
    gain: '1.0'
    samp_rate: rxSampleRate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: rxOverSample
  id: variable
  parameters:
    value: ceil(200000 / rxSampleRate)
  states: {}
- name: rxSampleRate
  id: variable
  parameters:
    value: rxSamplesPerSymbol * rxBaudRate
  states: {}
- name: rxSamplesPerSymbol
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sendFlags
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Send Inter-frame Flags
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: txBaseband
  id: variable
  parameters:
    value: 145.83E6
  states: {}
- name: txBaudRate
  id: variable
  parameters:
    value: rxBaudRate
  states: {}
- name: txCorrection
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txFrequencyDeviation
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: txFrequencyOffset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: txGain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '65'
    value: '48'
  states: {}
- name: txSampleRate
  id: variable
  parameters:
    value: txSamplesPerSymbol * txBaudRate
  states: {}
- name: txSamplesPerSymbol
  id: variable
  parameters:
    value: '120'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1E-1'
    decay_rate: '1E-2'
    gain: '1.0'
    max_gain: '65536'
    maxoutbuf: '1024'
    reference: '0.5'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/Desktop/ground_station/testing/recordings/07-24-2022_b210_RADSAT-SK x20_trans
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '500'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: txBaseband
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: rxBaseband
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: txSampleRate
    type: complex
  states: {state: bypassed}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfrom skyfield.api import load, wgs84\nimport serial\nimport time\nimport sys\n\nclass rigControl:\n    def __init__(self,lat,lon,satNum):\n        self.ts = load.timescale()\n\n        self.gs = wgs84.latlon(lat,lon)\n\n        satellites = load.tle_file(\"/home/radsat-gs/Desktop/austinsWorkspace/ground_station/src/active.txt\")\n        print(\"Loaded %s satellites\" % len(satellites))\n\n        catalog = {sat.model.satnum: sat for sat in satellites}\n        self.satellite = catalog[satNum]\n        print(self.satellite)\n\n    def getAzEl(self):\n        dist = self.satellite - self.gs\n        position = dist.at((self.ts).now())\n\n        el, az, _ = position.altaz()\n\n        return az.degrees, el.degrees\n\n    def isPass(self):\n        _, el = self.getAzEl()\n\n        if el > 5:\n            return True\n        else:\n            return False\n\n    def getDoppler(self,UL_FREQ,DL_FREQ,updateFiles = True):\n        dt = 1/86400\n        t1 = (self.ts).now() - dt\n        t2 = (self.ts).now()\n        t3 = (self.ts).now() + dt\n\n        comp1 = self.satellite.at(t1) - self.gs.at(t1)\n        comp2 = self.satellite.at(t2) - self.gs.at(t2)\n        comp3 = self.satellite.at(t3) - self.gs.at(t3)\n\n        dists = [comp1.distance().m,comp2.distance().m,comp3.distance().m]\n        satRate = abs((np.gradient(dists))[2])\n\n        ul_doppler = satRate * UL_FREQ / 299792458\n        dl_doppler = satRate * DL_FREQ / 299792458\n \n        print(\"Sat Rate:\",satRate)\n\n        print('UL Doppler: {:.1f} Hz'.format(ul_doppler))\n        print('DL Doppler: {:.1f} Hz'.format(dl_doppler))\n\n        if comp3.distance().m <= comp1.distance().m: # Approaching\n            UL_FREQ_shifted = UL_FREQ - ul_doppler\n            DL_FREQ_shifted = DL_FREQ + dl_doppler\n            print(\"Approaching\")\n\n        elif comp3.distance().m > comp1.distance().m: # Leaving\n            UL_FREQ_shifted = UL_FREQ + ul_doppler\n            DL_FREQ_shifted = DL_FREQ - dl_doppler\n            print(\"Leaving\")        \n\n        if updateFiles:\n            timeTime = time.time()\n            with open(\"ul_doppler.txt\",\"w\") as ul, open(\"dl_doppler.txt\",\"w\") as dl:\n                ul.write(str(timeTime) + \" \" + str(ul_doppler))\n                dl.write(str(timeTime) + \" \" + str(dl_doppler))\n                print()\n\n\n        return UL_FREQ_shifted, DL_FREQ_shifted\n\n    def getPassTimes(self, year, month, day, el = 5):\n        start = self.ts.utc(year,month,day)\n        stop  = self.ts.utc(year,month,day + 1)\n\n        t,events = self.satellite.find_events(self.gs,start,stop,altitude_degrees = 5.0)\n        eventNames = 'rise above %s°' % el, 'culminate', 'set below 5°'\n        for ti, event in zip(t, events):\n            name = eventNames[event]\n            print(ti.utc_strftime('%Y %b %d %H:%M:%S'), name)\n\n        return t,events\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, upBaseFreq=100e6, dnBaseFreq=100e6, gsLat=52.144176, gsLon=-106.612910):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Doppler Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n\n        try:\n            noradId = int(sys.argv[1])\n\n        except IndexError:\n            print(\"No TLE given, defaulting to ISS = 25544\\n\")\n            noradId = 25544\n\n        self.uplinkFreq = upBaseFreq\n        self.dnlinkFreq = dnBaseFreq\n        self.controller = rigControl(gsLat, gsLon, noradId)\n        \n        # Register message ports\n        self.message_port_register_out(pmt.intern('uplk_freq_msg'))\n        self.message_port_register_out(pmt.intern('dnlk_freq_msg'))\n        self.message_port_register_out(pmt.intern('pass_msg'))\n        self.message_port_register_in(pmt.intern('update_msg'))\n        self.set_msg_handler(pmt.intern('update_msg'), self.sendInfo)\n        \n    def sendInfo(self, msg):\n        upFreq, dnFreq = self.controller.getDoppler(self.uplinkFreq, self.dnlinkFreq)\n        isInPass = self.controller.isPass()\n        self.message_port_pub(pmt.intern('uplk_freq_msg'), pmt.cons(pmt.intern('value'),    pmt.to_pmt(upFreq)))\n        self.message_port_pub(pmt.intern('dnlk_freq_msg'), pmt.cons(pmt.intern('value'),    pmt.to_pmt(dnFreq)))\n        self.message_port_pub(pmt.intern('pass_msg'),      pmt.cons(pmt.intern('pass_msg'), pmt.to_pmt(isInPass)))\n        \n    def stop(self):\n        return True\n\n"
    dnBaseFreq: rxBaseband
    gsLat: '52.144176'
    gsLon: '-106.61291'
    upBaseFreq: txBaseband
  states: {}
- name: fskMod_0
  id: fskMod
  parameters:
    baudRate: '9600'
    frequencyDeviation: '3500'
    maxoutbuf: '100'
    samplesPerSymbol: txSamplesPerSymbol
  states: {}
- name: gmskDemod_0
  id: gmskDemod
  parameters:
    sampleRate: rxSampleRate
    samplesPerSymbol: rxSamplesPerSymbol
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, ceil
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rxSampleRate
    color1: '"dark green"'
    color2: '"dark blue"'
    fc: rxBaseband
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1:1,0,1,1
    label1: Post Filtering
    label2: Pre Filtering
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.016'
    width1: '2'
    width2: '2'
    ymax: '1'
    ymin: '-250'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: txSampleRate
    fc: txBaseband
    fftsize: '1024'
    gui_hint: tabs@0:3,0,1,1
    name: '"Pre Demod"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: rxSampleRate
    fc: rxBaseband
    fftsize: '16384'
    gui_hint: tabs@1:2,0,1,1
    name: '"Rx Spectrum (Pre-AGC)"'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: rxSampleRate
    fc: rxBaseband
    fftsize: '512'
    gui_hint: tabs@1:3,0,1,1
    name: '"Rx Spectrum (Post-AGC)"'
    plotconst: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    gui_hint: tabs@0:4,0,1,1
    legend: 'False'
    size: 8*32
    srate: txSampleRate
    tr_tag: '"pkt_length"'
    type: float
    update_time: '0.016'
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rxBaseband + rxCorrection
    gain0: rxGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rxSampleRate*rxOverSample
    sync: sync
    type: fc32
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Tx Tab
    label1: Rx Tab
    num_tabs: '2'
  states: {}
- name: trxvuAx25Deframer_0
  id: trxvuAx25Deframer
  parameters: {}
  states: {}
- name: trxvuAx25Framer_0
  id: trxvuAx25Framer
  parameters:
    EnableInterFrameFill: sendFlags
    SamplesPerSymbol: txSamplesPerSymbol
    destinationCallsign: radsatCallsign
    destinationSsid: '1'
    maxoutbuf: '8192'
    sourceCallsign: radsatCallsign
    sourceSsid: '10'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: txBaseband
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: txGain
    len_tag_name: '"tx_pkt_len"'
    maxoutbuf: '255'
    samp_rate: txSampleRate
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rxBaseband + rxFrequencyOffset*0 + rxCorrection
    dev_addr: '"serial=31E34AD"'
    dev_args: name=MyB210,product=B210
    gain0: rxGain
    samp_rate: rxSampleRate*rxOverSample
    sync: sync
    type: fc32
  states: {}
- name: xlatingFIRfilter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '- rxFrequencyOffset*0'
    decim: rxOverSample
    samp_rate: rxSampleRate
    taps: rxLowPassFilterTap
    type: ccc
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:15531
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:15530
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [analog_agc2_xx_0, '0', gmskDemod_0, '0']
- [analog_agc2_xx_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_file_source_1, '0', xlatingFIRfilter, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, update_msg]
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, dnlk_freq_msg, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, uplk_freq_msg, blocks_msgpair_to_var_0, inpair]
- [fskMod_0, '0', blocks_throttle_0, '0']
- [gmskDemod_0, '2', trxvuAx25Deframer_0, '0']
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [qtgui_freq_sink_x_0, freq, xlatingFIRfilter, freq]
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '1']
- [rtlsdr_source_0, '0', xlatingFIRfilter, '0']
- [trxvuAx25Deframer_0, msg_out, zeromq_push_msg_sink_0, in]
- [trxvuAx25Framer_0, '0', blocks_char_to_float_0, '0']
- [trxvuAx25Framer_0, '0', fskMod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', xlatingFIRfilter, '0']
- [xlatingFIRfilter, '0', analog_agc2_xx_0, '0']
- [xlatingFIRfilter, '0', qtgui_freq_sink_x_0, '0']
- [xlatingFIRfilter, '0', qtgui_sink_x_1, '0']
- [zeromq_sub_msg_source_0, out, trxvuAx25Framer_0, Info in]

metadata:
  file_format: 1
