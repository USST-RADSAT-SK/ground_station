options:
  parameters:
    author: Austin
    generate_options: qt_gui
    id: RFMReceiver
    output_language: python
    realtime_scheduling: '1'
    title: RFMReceiver
  states: {}

blocks:
- name: audioSampleRate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 0.025e6
    stop: 1.6e9
    value: 95.1e6
    widget: counter
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: rfSampleRate
  id: variable
  parameters:
    value: audioSampleRate * 25
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: rfSampleRate // audioSampleRate
    quad_rate: rfSampleRate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: audioSampleRate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: 1e6
    digital_bandw_ch1: rfSampleRate
    gain_dB_ch0: rfGain
    gain_dB_ch1: '70'
    oversample: '0'
    rf_freq: frequency
    samp_rate: rfSampleRate
    serial: 1D538ACAE2BD00
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: rfSampleRate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: mainTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,2
    label0: RF
    label1: Audio
    num_tabs: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    note: LimeSDR
  states: {}
- name: note_1
  id: note
  parameters:
    note: RTL-SDR
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: rfSampleRate
    fc: frequency
    fftsize: '1024'
    gui_hint: mainTabs@0
    plotconst: 'False'
    plottime: 'False'
    rate: '20'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: mainTabs@1
    legend: 'False'
    size: '1024'
    srate: audioSampleRate
    type: float
    update_time: 1/20
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: bandwidth
    freq0: frequency
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rfSampleRate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
