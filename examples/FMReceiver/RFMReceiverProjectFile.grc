options:
  parameters:
    author: Austin
    generate_options: qt_gui
    id: RFMReceiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: audioSampleRate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: carrierFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Carrier Frequency (Hz)
    orient: Qt.Horizontal
    start: 50e6
    step: 0.025e6
    stop: 1.6e9
    value: 95.1e6
    widget: counter
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: rxSampleRate
  id: variable
  parameters:
    value: audioSampleRate * 25
  states: {}
- name: audioSink
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: audioSampleRate
  states: {}
- name: audioTimeSink
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 3,1,1,1
    legend: 'False'
    size: '1024'
    srate: audioSampleRate
    type: float
    update_time: 1/20
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: fmDemodulator
  id: analog_wfm_rcv
  parameters:
    audio_decimation: rxSampleRate // audioSampleRate
    quad_rate: rxSampleRate
  states: {}
- name: guiSink
  id: qtgui_sink_x
  parameters:
    bw: rxSampleRate
    fc: carrierFrequency
    fftsize: '1024'
    gui_hint: 3,0,1,1
    plotconst: 'False'
    plottime: 'False'
    rate: '20'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: limeSDRSource
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: 1e6
    digital_bandw_ch1: '0'
    gain_dB_ch0: rxGain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: carrierFrequency
    samp_rate: rxSampleRate
    serial: 1D538ACAE2BD00
  states: {state: disabled}
- name: lowPassFilter
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: rxSampleRate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rtlSDRSource
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: carrierFrequency
    gain0: rxGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rxSampleRate
    sync: none
    type: fc32
  states: {}

connections:
- [fmDemodulator, '0', audioSink, '0']
- [fmDemodulator, '0', audioTimeSink, '0']
- [limeSDRSource, '0', guiSink, '0']
- [limeSDRSource, '0', lowPassFilter, '0']
- [lowPassFilter, '0', fmDemodulator, '0']
- [rtlSDRSource, '0', guiSink, '0']
- [rtlSDRSource, '0', lowPassFilter, '0']

metadata:
  file_format: 1
