options:
  parameters:
    author: Austin
    generate_options: qt_gui
    id: RFMTransmitter
    output_language: python
    title: RFMTransmitterProject
  states: {}

blocks:
- name: TransmitVolume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: audioSampleRate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 160e3
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 107.1e6
  states: {}
- name: preModSampleRate
  id: variable
  parameters:
    value: bandwidth+50e3
  states: {}
- name: preModSampleRatio
  id: variable
  parameters:
    value: audioSampleRate / preModSampleRate
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: txSampleRate
  id: variable
  parameters:
    value: int(preModSampleRate * 5)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(preModSampleRate)
    fh: '-1.0'
    max_dev: bandwidth // 2 - 5000
    quad_rate: int(txSampleRate)
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: TransmitVolume
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: BrittleRilleByKevinMacLeod.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch0: frequency
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: bandwidth
    digital_bandw_ch1: '0'
    gain_dB_ch0: rfGain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: frequency
    samp_rate: txSampleRate
  states: {}
- name: mmse_interpolator_xx_0
  id: mmse_interpolator_xx
  parameters:
    interp_ratio: preModSampleRatio
    phase_shift: '0'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: txSampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,2
    plottime: 'False'
    rate: '20'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [analog_wfm_tx_0, '0', limesdr_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', mmse_interpolator_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [mmse_interpolator_xx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
