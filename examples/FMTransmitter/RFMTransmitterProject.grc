options:
  parameters:
    author: Austin
    generate_options: qt_gui
    id: RFMTransmitter
    output_language: python
    title: RFMTransmitterProject
  states: {}

blocks:
- name: TransmitVolume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: audioSampleRate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 107.1e6
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: rfSampleRate
  id: variable
  parameters:
    value: int(audioSampleRate * 25)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audioSampleRate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: rfSampleRate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: TransmitVolume
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: BrittleRilleByKevinMacLeod.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: rfSampleRate
    digital_bandw_ch1: rfSampleRate
    gain_dB_ch0: rfGain
    oversample: '0'
    rf_freq: frequency
    samp_rate: rfSampleRate
  states: {}
- name: mainTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,2
    label0: RF
    label1: Audio
    num_tabs: '2'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: rfSampleRate
    fc: frequency
    fftsize: '1024'
    gui_hint: 2,0,1,2
    plotconst: 'False'
    plottime: 'False'
    rate: '20'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_tx_0, '0', limesdr_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_1, '0']

metadata:
  file_format: 1
