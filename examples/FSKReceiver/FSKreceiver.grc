options:
  parameters:
    author: austin
    comment: '{python} -u {filename}'
    generate_options: qt_gui
    id: FSKreceiver
    output_language: python
    run_command: gnome-terminal -- bash -c "{python} -u {filename}; echo type enter to exit; read"
    title: FSK receiver
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Data Comparison Position
    orient: Qt.Horizontal
    start: '-16*8'
    step: '1'
    stop: 16*8
    value: '0'
  states: {}
- name: filw
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: filter Width
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '25000'
    value: baud
  states: {}
- name: filw
  id: variable
  parameters:
    value: '1000'
  states: {state: disabled}
- name: filwsize
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: filwsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: filter size
    orient: Qt.Horizontal
    start: '-7000'
    step: '50'
    stop: '7000'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: freqDeviation
  id: variable
  parameters:
    value: baud//2
  states: {}
- name: freqError
  id: variable
  parameters:
    value: '200'
  states: {}
- name: rxgain
  id: variable
  parameters:
    value: '60'
  states: {state: disabled}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    threshold: '0'
  states: {}
- name: CLIPrintSink
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\ndef limitChr(chars):\n    if not isinstance(chars, list):\n        chars = [chars]\n    output = ''\n    for i in chars:\n        if ((0x1f < i < 0x7f) and i != 0x8d) or i == 10 or (0xa0 < i <= 0xff):\n            output += chr(i)\n    return output\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, flag=0b01111110, maxLen=255, minLen=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='CLI Print Sink',   # will show up in GRC\n            in_sig=[np.int8],\n            out_sig=None  # out_sig=[np.uint8]\n        )\n        self.flag = flag\n        self.max = maxLen - 16\n        self.min = minLen - 16\n        self.startFlag = 0\n        self.endFlag = 0\n        self.body = []\n        self.bodySize = 0\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n\n    def work(self, input_items, output_items):\n        inputLength = len(input_items)\n        i = 0\n        while i < inputLength:\n            if len(self.body) > self.max:\n                self.startFlag = 0\n                self.endFlag = 0\n                self.body = []\n            if self.startFlag != self.flag:\n                self.startFlag = ((self.startFlag << 1) + input_items[0][i]) & 0xff\n            elif self.endFlag != self.flag:\n                self.body.append(str((self.endFlag & 0b10000000) >> 7))\n                self.endFlag = ((self.endFlag << 1) + input_items[0][i]) & 0xff\n            elif self.startFlag == self.flag and self.endFlag == self.flag:\n                if not len(self.body) % 8 and len(self.body) > self.min:\n                    \n                    print(f'{len(input_items[0]): 4} - {\"\".join(self.body[8:])}')\n                self.startFlag = 0\n                self.endFlag = 0\n                self.body = []\n            i += 1\n        self.consume(0,inputLength) # empty input. fixes overflow\n        return 0\n        \n"
    flag: '0b01111110'
    maxLen: '255'
    minLen: '136'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.8'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/austin/Documents/usst/ground_station/examples/SampleBinaryFiles/pyramid_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0001'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: filwsize
    decim: '4'
    samp_rate: samp_rate*3
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    gain_dB_ch0: rxgain
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate* 4
    serial: 1D538ACAE2BD00
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filw + freqError
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: freqError
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: rxgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*4
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 11,0,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: baud
    fc: freq
    fftsize: '1024'
    gui_hint: 12,0,1,1
    name: '"Pre Process"'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate * 4
    fc: freq
    fftsize: 1024*4
    gui_hint: 13,0,1,1
    name: '"Pre Process"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: TX Binary
    label2: RX Binary Demod
    nconnections: '2'
    size: 32*8*2
    srate: '1'
    stemplot: 'True'
    type: float
    update_time: 1/30
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '1']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', CLIPrintSink, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_1_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_1_0, '0']
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
