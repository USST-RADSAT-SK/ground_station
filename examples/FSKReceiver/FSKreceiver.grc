options:
  parameters:
    author: austin
    generate_options: qt_gui
    id: FSKreceiver
    output_language: python
    title: FSK receiver
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Data Comparison Position
    orient: Qt.Horizontal
    start: '-16*8'
    step: '1'
    stop: 16*8
    value: '0'
  states: {}
- name: filw
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: filter Width
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '15000'
    value: '5800'
  states: {}
- name: filwsize
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: filter size
    orient: Qt.Horizontal
    start: '0'
    step: '50'
    stop: filw
    value: '500'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 107.1e6
  states: {}
- name: freqDeviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: freqError
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '65'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.8'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*freqDeviation/1.0)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filw + filwsize
    low_cutoff_freq: filw -filwsize
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/ground_station/examples/SampleBinaryFiles/pyramid_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '230'
    min: '32'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\ndef limitChr(chars):\n    if not isinstance(chars, list):\n        chars = [chars]\n    output = ''\n    for i in chars:\n        if ((0x1f < i < 0x7f) and i != 0x8d) or i == 10 or (0xa0 < i <= 0xff):\n            output += chr(i)\n    return output\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, format_string=\"{}\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='CLI Print Sink',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=None  # out_sig=[np.uint8]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.fromat_string = format_string\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        printString = ''\n        for i in input_items[0]:\n        \tif 0 <= i+127 <= 255:\n        \t\tprintString += str(chr(i+127))\n        \telse:\n        \t\tprintString += '\\n' + str(i+127) + '\\n'\n        print(printString)\n        return 0\n        \n"
    format_string: '''{}'''
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: rxgain
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filw + freqError
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: freqError
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: rxgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 11,0,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: baud
    fc: freq
    fftsize: '1024'
    gui_hint: 12,0,1,1
    name: '"Pre Process"'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: RX Binary Actual
    label2: RX Binary Demod
    nconnections: '2'
    size: 32*8*2
    srate: '1'
    stemplot: 'True'
    type: float
    update_time: 1/30
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sps
    interp: '1'
    taps: '1'
    type: fff
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', analog_agc_xx_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [limesdr_source_0, '0', band_pass_filter_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
