options:
  parameters:
    author: austin
    comment: '{python} -u {filename}'
    generate_options: qt_gui
    id: RFSKReceiver
    output_language: python
    run_command: gnome-terminal -- bash -c "{python} -u {filename}; echo type enter to exit; read"
    title: FSK Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: baudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: carrierFrequency
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: exampleDelay
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Data Comparison Position
    orient: Qt.Horizontal
    start: '-16*8'
    step: '1'
    stop: 16*8
    value: '0'
  states: {}
- name: filterWidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Filter Width
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '25000'
    value: frequencyDeviation
  states: {}
- name: frequencyDeviation
  id: variable
  parameters:
    comment: |-
      BW = 2 * (f_r + delta f)

      delta f = carrier frequency
      f_r = datarate (baud for FSK)
      BW = bandwidth
    value: abs(bandwidth//2 - baudRate)
  states: {}
- name: frequencyOffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: filter size
    orient: Qt.Horizontal
    start: '-7000'
    step: '50'
    stop: '7000'
    value: '0'
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: samplePerSecond
  id: variable
  parameters:
    value: '30'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: baudRate * samplePerSecond
  states: {}
- name: CLIPrintSink
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\ndef limitChr(chars):\n    if not isinstance(chars, list):\n        chars = [chars]\n    output = ''\n    for i in chars:\n        if ((0x1f < i < 0x7f) and i != 0x8d) or i == 10 or (0xa0 < i <= 0xff):\n            output += chr(i)\n    return output\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, flag=0b01111110, maxLen=255, minLen=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='CLI Print Sink',   # will show up in GRC\n            in_sig=[np.int8],\n            out_sig=None  # out_sig=[np.uint8]\n        )\n        self.flag = flag\n        self.max = maxLen - 16\n        self.min = minLen - 16\n        self.startFlag = 0\n        self.endFlag = 0\n        self.body = []\n        self.bodySize = 0\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n\n    def work(self, input_items, output_items):\n        inputLength = len(input_items)\n        i = 0\n        while i < inputLength:\n            if len(self.body) > self.max:\n                self.startFlag = 0\n                self.endFlag = 0\n                self.body = []\n            if self.startFlag != self.flag:\n                self.startFlag = ((self.startFlag << 1) + input_items[0][i]) & 0xff\n            elif self.endFlag != self.flag:\n                self.body.append(str((self.endFlag & 0b10000000) >> 7))\n                self.endFlag = ((self.endFlag << 1) + input_items[0][i]) & 0xff\n            elif self.startFlag == self.flag and self.endFlag == self.flag:\n                if not len(self.body) % 8 and len(self.body) > self.min:\n                    \n                    print(f'{len(input_items[0]): 4} - {\"\".join(self.body[8:])}')\n                self.startFlag = 0\n                self.endFlag = 0\n                self.body = []\n            i += 1\n        self.consume(0,inputLength) # empty input. fixes overflow\n        return 0\n        \n"
    flag: '0b01111110'
    maxLen: '255'
    minLen: '136'
  states: {}
- name: FSKDemod
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baudRate
    iq: 'True'
    samp_rate: sampleRate
    subaudio: 'False'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.8'
    type: complex
  states: {}
- name: binarySlicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: bitCompariosn
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: TX Binary
    label2: RX Binary Demod
    nconnections: '2'
    size: 32*8*2
    srate: '1'
    stemplot: 'True'
    type: float
    update_time: 1/30
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: compairUCharToFloat
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: delayExample
  id: blocks_delay
  parameters:
    delay: exampleDelay
    type: float
  states: {}
- name: exampleFileSource
  id: blocks_file_source
  parameters:
    file: /home/austin/Documents/usst/ground_station/examples/SampleBinaryFiles/pyramid_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: exampleUnpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: invertExample
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: limeSDRSource
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: sampleRate
    digital_bandw_ch1: sampleRate
    gain_dB_ch0: rxGain
    oversample: '0'
    rf_freq: carrierFrequency
    samp_rate: sampleRate * 4
  states: {state: disabled}
- name: lowPassCompairSink
  id: qtgui_freq_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 11,0,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: multiplyConst
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0001'
    type: complex
  states: {}
- name: osmoSDRSource
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: carrierFrequency
    gain0: rxGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sampleRate * 4
    sync: none
    type: fc32
  states: {}
- name: postDemodGUISink
  id: qtgui_sink_x
  parameters:
    bw: baudRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 12,0,1,1
    name: '"Post Demod"'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: preDemodLowPassFilter
  id: low_pass_filter
  parameters:
    cutoff_freq: filterWidth
    decim: '1'
    gain: '1'
    samp_rate: sampleRate
    type: fir_filter_ccf
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: preTranslateGUISink
  id: qtgui_sink_x
  parameters:
    bw: sampleRate * 4
    fc: carrierFrequency
    fftsize: 1024*4
    gui_hint: 13,0,1,1
    name: '"Pre Translate"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: uCharToFloat
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: xlatingFIRfilter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: frequencyOffset
    decim: '4'
    samp_rate: sampleRate * 4
    taps: '1'
    type: ccc
  states: {}

connections:
- [FSKDemod, '0', binarySlicer, '0']
- [FSKDemod, '0', postDemodGUISink, '0']
- [agc, '0', FSKDemod, '0']
- [agc, '0', lowPassCompairSink, '0']
- [binarySlicer, '0', CLIPrintSink, '0']
- [binarySlicer, '0', uCharToFloat, '0']
- [compairUCharToFloat, '0', invertExample, '0']
- [delayExample, '0', bitCompariosn, '0']
- [exampleFileSource, '0', exampleUnpack, '0']
- [exampleUnpack, '0', compairUCharToFloat, '0']
- [invertExample, '0', delayExample, '0']
- [limeSDRSource, '0', preTranslateGUISink, '0']
- [limeSDRSource, '0', xlatingFIRfilter, '0']
- [multiplyConst, '0', lowPassCompairSink, '1']
- [multiplyConst, '0', preDemodLowPassFilter, '0']
- [osmoSDRSource, '0', preTranslateGUISink, '0']
- [osmoSDRSource, '0', xlatingFIRfilter, '0']
- [preDemodLowPassFilter, '0', agc, '0']
- [uCharToFloat, '0', bitCompariosn, '1']
- [xlatingFIRfilter, '0', multiplyConst, '0']

metadata:
  file_format: 1
