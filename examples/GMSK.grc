options:
  parameters:
    generate_options: qt_gui
    id: gmsk
    output_language: python
    title: GMSK
  states: {}

blocks:
- name: BT
  id: variable
  parameters:
    comment: bandwidth to bitrate ratio
    value: '0.30'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-32*8'
    step: '1'
    stop: 32*8
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud * samplesPerSymbol
  states: {}
- name: samplesPerSymbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: symbolRate
  id: variable
  parameters:
    value: baud
  states: {}
- name: t1
  id: variable
  parameters:
    value: firdes.gaussian(1, samp_rate, baud/2, samplesPerSymbol)
  states: {}
- name: variable_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/ground_station/examples/SampleBinaryFiles/alternating_bits.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samplesPerSymbol
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: samplesPerSymbol
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '300e-3'
    samples_per_symbol: samplesPerSymbol
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[0.010465437546372414,0.012803290039300919,0.015447097830474377,0.018379483371973038,0.02156655490398407,0.024956824257969856,0.028481246903538704,0.03205455467104912,0.03557800129055977,0.03894345462322235,0.04203862324357033,0.04475314915180206,0.04698506370186806,0.048647113144397736,0.049672432243824005,0.05001898854970932,0.049672432243824005,0.048647113144397736,0.04698506370186806,0.04475314915180206,0.04203862324357033,0.03894345462322235,0.03557800129055977,0.03205455467104912,0.028481246903538704,0.024956824257969856,0.02156655490398407,0.018379483371973038,0.015447097830474377,0.012803290039300919,0.010465437546372414,0.008436343632638454]'
    type: fff
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '9600'
    fc: '0'
    fftsize: '1024'
    rate: samplesPerSymbol
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samplesPerSymbol
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: After Demod
    label2: Difference
    label3: Before Mod
    nconnections: '3'
    size: 32*8*2
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: After Demod
    size: 32*8*2*samplesPerSymbol
    srate: samplesPerSymbol
    stemplot: 'True'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.33'
    alpha2: '0.33'
    label1: '0.5'
    label2: '1.0'
    nconnections: '2'
    size: 32*8*samplesPerSymbol
    srate: samplesPerSymbol
    stemplot: 'True'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_repeat_0, '0']
- [blocks_delay_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_file_source_0, '0', blocks_head_1, '0']
- [blocks_head_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_head_1, '0', digital_gmsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_repeat_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_repeat_0, '0', qtgui_sink_x_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_1_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_throttle_0, '0', digital_gmsk_demod_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_gmsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gmsk_mod_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_1_0_0, '0']

metadata:
  file_format: 1
