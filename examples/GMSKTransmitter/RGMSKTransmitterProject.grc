options:
  parameters:
    author: austin
    generate_options: qt_gui
    id: FSKTransmitter
    output_language: python
    title: FSK Transmitter
  states: {}

blocks:
- name: baudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: carrierFrequency
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: freqError
  id: variable
  parameters:
    value: '200'
  states: {}
- name: frequencyDeviation
  id: variable
  parameters:
    value: baudRate//2
  states: {}
- name: samplesPerSymbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: txSampleRate
  id: variable
  parameters:
    value: baudRate * samplesPerSymbol
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Tx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/austin/Documents/usst/ground_station/examples/SampleBinaryFiles/pyramid_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: samplesPerSymbol
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    comment: 1D53B0399E11FA
    digital_bandw_ch0: frequencyDeviation+freqError
    digital_bandw_ch1: '0'
    gain_dB_ch0: txgain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: carrierFrequency
    samp_rate: txSampleRate
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: txSampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@0:3,0,1,1
    label1: Tx Binary
    label2: ''
    marker1: '8'
    size: 1024 * 2
    srate: txSampleRate
    stemplot: 'True'
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 10,0,1,1
    label0: Tx
    label1: FSK Mod
    num_tabs: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_mod_0, '0', limesdr_sink_0_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_sink_x_0_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
