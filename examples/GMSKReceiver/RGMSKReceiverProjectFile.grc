options:
  parameters:
    author: austin
    comment: '{python} -u {filename}'
    generate_options: qt_gui
    id: RGMSKReceiver
    output_language: python
    run_command: gnome-terminal -- bash -c "{python} -u {filename}; echo type enter to exit; read"
    title: GMSK Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: baudRate//2 + freqError
  states: {}
- name: baudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: carrierFrequency
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: exampleDelay
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Data Comparison Position
    orient: Qt.Horizontal
    start: '-16*8'
    step: '1'
    stop: 16*8
    value: '0'
  states: {}
- name: filterWidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Width
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '25000'
    value: frequencyDeviation
  states: {}
- name: freqError
  id: variable
  parameters:
    value: '200'
  states: {}
- name: frequencyDeviation
  id: variable
  parameters:
    value: baudRate//2
  states: {}
- name: frequencyOffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Offset
    orient: Qt.Horizontal
    start: '-7000'
    step: '50'
    stop: '7000'
    value: '0'
  states: {}
- name: rxGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '70'
    value: '0'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: baudRate * samplesPerSymbol
  states: {}
- name: samplesPerSymbol
  id: variable
  parameters:
    value: '30'
  states: {}
- name: RCLIPrintSink
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\n\ndef limitChr(chars):\n    \"\"\"\n    Routine to convert a intiger to a ASCII character but exclude non-visual SCHII codes.\n\n        chars: a integer or a list of integers representing a ASCII code.\n\n       return: a string of converted ASCII characters.\n    \"\"\"\n    if not isinstance(chars, (list, np.ndarray)):\n        chars = [chars]\n    output = \"\"\n    for i in chars:\n        if ((0x1F < i < 0x7F) and i != 0x8D) or i == 10 or (0xA0 < i <= 0xFF):\n            output += chr(i)\n    return output\n\ndef insertBit(val, boolVal):\n    return (val << type(val)(1)) + boolVal\n\n\nclass deframer:\n    def __init__(self, flag=0b01111110, maxLen=255, minLen=0):\n        self._flag = flag\n        self._max = maxLen - 8  # subtract flag lengths\n        self._min = minLen - 8\n        self.__startFlag = np.uint8(0)\n        self.__endFlag = np.uint8(0)\n        self.__body = np.zeros((maxLen,), dtype=np.uint8)\n        self.__bodyLen = -8\n        self.__outputBuffer = []\n\n\n    def work(self, input_items):\n        \"\"\"\n        This is where the work is done in the GNURadio block.\n\n        algorith: double slidding window searching for start/end flag with both windows\n        encapsulating the message body implemented as state mechine.\n        \"\"\"\n        inputLength = len(input_items)\n        output = []\n        i = 0\n        while i < inputLength:  # Recursive like algorithm.\n            if self.__bodyLen >= self._max:  # Reset window message body to bigger them max.\n                self.__startFlag = np.uint8(0)\n                self.__endFlag = np.uint8(0)\n                self.__bodyLen = -8\n            if self.__startFlag != self._flag:  # Case: first flas search.\n                self.__startFlag = insertBit(self.__startFlag, input_items[i])\n            elif self.__endFlag != self._flag:  # Case: last flag search.\n                if self.__bodyLen >= 0:\n                    self.__body[self.__bodyLen // 8] = insertBit(self.__body[self.__bodyLen // 8], self.__endFlag >> np.uint8(7))\n                self.__endFlag = insertBit(self.__endFlag, input_items[i])\n                self.__bodyLen += 1\n            elif (self.__startFlag == self._flag and self.__endFlag == self._flag):  # Case: message found and validation.\n                if not self.__bodyLen % 8 and self.__bodyLen >= self._min:\n                    output.append(self.__body[0:self.__bodyLen//8])\n                self.__startFlag = np.uint8(0)\n                self.__endFlag = np.uint8(0)\n                self.__bodyLen = -8\n            i += 1\n        return output\n        \n        \nclass blk(gr.sync_block):\n    def __init__(self, flag=0b01111110, maxLen=255, minLen=0):\n        gr.sync_block.__init__(\n            self,\n            name=\"CLI Print Sink\",\n            in_sig=[np.uint8],\n            out_sig=None,\n        )\n        self.deframerObj = deframer(flag, maxLen, minLen)\n        \n    def work(self, input_items, output_items):\n        for i in self.deframerObj.work(input_items[0]):\n            # print(('{:02X}'*len(i)).format(*i))\n            print(limitChr(i))\n            # print('{:<.60s}'.format(''.join([f\"{J:02X}\" for J in i])))\n        self.consume(0, len(input_items[0]))  # empty input. fixes overflow\n        return 0\n\nif __name__ == \"__main__\":\n    testobj = deframer() \n    \n    flag = f'{0x7e:08b}'\n    body = \"000000000000000\"+flag\n    bodyText = \"test text 1234\"\n    hexBody =  ''\n    for i in bodyText:\n        hexBody += f'{ord(i):02X}'\n        body += f'{ord(i):08b}'\n    body += flag+\"00000000000000000\"\n    data = []\n    for i in body:\n        data.append(np.uint8(int(i)))\n    print(hexBody)\n    testobj.work((data,),data)\n    \n    \n"
    flag: '0b01111110'
    maxLen: 255*8
    minLen: 16 * 8
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.8'
    type: complex
  states: {}
- name: bitCompariosn
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: TX Binary
    label2: RX Binary Demod
    nconnections: '2'
    size: 32*8*2
    srate: '1'
    stemplot: 'True'
    type: float
    update_time: 1/30
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: compairUCharToFloat
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: delayExample
  id: blocks_delay
  parameters:
    delay: exampleDelay
    type: float
  states: {}
- name: exampleFileSource
  id: blocks_file_source
  parameters:
    file: /home/radsat-gs/ground_station/examples/SampleBinaryFiles/50p_duty_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: exampleUnpack
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: gmskDemod
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: samplesPerSymbol
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: invertExample
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: limeSDRSource
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: sampleRate
    digital_bandw_ch1: sampleRate
    gain_dB_ch0: rxGain
    oversample: '0'
    rf_freq: carrierFrequency
    samp_rate: sampleRate * 4
  states: {state: disabled}
- name: lowPassCompairSink
  id: qtgui_freq_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 11,0,1,1
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-200'
  states: {}
- name: multiplyConst
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0001'
    type: complex
  states: {}
- name: osmoSDRSource
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: carrierFrequency
    gain0: rxGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sampleRate * 4
    sync: none
    type: fc32
  states: {state: disabled}
- name: postDemodGUISink
  id: qtgui_sink_x
  parameters:
    bw: baudRate
    fc: '0'
    fftsize: '1024'
    gui_hint: 12,0,1,1
    name: '"Post Demod"'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: preDemodLowPassFilter
  id: low_pass_filter
  parameters:
    cutoff_freq: filterWidth
    decim: '1'
    gain: '1'
    samp_rate: sampleRate
    type: fir_filter_ccf
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: preTranslateGUISink
  id: qtgui_sink_x
  parameters:
    bw: sampleRate * 4
    fc: carrierFrequency
    fftsize: 1024*4
    gui_hint: 13,0,1,1
    name: '"Pre Translate"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: uCharToFloat
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth*2
    center_freq0: carrierFrequency
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rxGain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: sampleRate * 4
    sync: sync
    type: fc32
  states: {}
- name: xlatingFIRfilter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: frequencyOffset
    decim: '4'
    samp_rate: sampleRate * 4
    taps: '1'
    type: ccf
  states: {}

connections:
- [agc, '0', gmskDemod, '0']
- [agc, '0', lowPassCompairSink, '0']
- [compairUCharToFloat, '0', invertExample, '0']
- [delayExample, '0', bitCompariosn, '0']
- [exampleFileSource, '0', exampleUnpack, '0']
- [exampleUnpack, '0', compairUCharToFloat, '0']
- [gmskDemod, '0', RCLIPrintSink, '0']
- [gmskDemod, '0', uCharToFloat, '0']
- [invertExample, '0', delayExample, '0']
- [limeSDRSource, '0', preTranslateGUISink, '0']
- [limeSDRSource, '0', xlatingFIRfilter, '0']
- [multiplyConst, '0', lowPassCompairSink, '1']
- [multiplyConst, '0', preDemodLowPassFilter, '0']
- [osmoSDRSource, '0', preTranslateGUISink, '0']
- [osmoSDRSource, '0', xlatingFIRfilter, '0']
- [preDemodLowPassFilter, '0', agc, '0']
- [uCharToFloat, '0', bitCompariosn, '1']
- [uCharToFloat, '0', postDemodGUISink, '0']
- [uhd_usrp_source_0, '0', preTranslateGUISink, '0']
- [uhd_usrp_source_0, '0', xlatingFIRfilter, '0']
- [xlatingFIRfilter, '0', multiplyConst, '0']

metadata:
  file_format: 1
