options:
  parameters:
    author: austin
    generate_options: qt_gui
    id: FSKTransmitter
    output_language: python
    title: FSK Transmitter
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: freqDeviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: freqError
  id: variable
  parameters:
    value: '100'
  states: {}
- name: isamp
  id: variable
  parameters:
    value: baud
  states: {state: disabled}
- name: isps
  id: variable
  parameters:
    value: sps
  states: {state: disabled}
- name: modGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Mod Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '5'
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud * sps
  states: {}
- name: sens
  id: variable
  parameters:
    value: '0.25'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: 32*4
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Tx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2* math.pi * (baud/ (sps*baud))
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '16'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2*isamp /sens
    offset: '0'
    phase: '0'
    samp_rate: isamp * isps
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: isamp / sens
    offset: '0'
    phase: '0'
    samp_rate: isamp * isps
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baud
    offset: '0'
    phase: math.pi/-4*0
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baud
    offset: '0'
    phase: math.pi*1/2-math.pi
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/austin/Documents/usst/ground_station/examples/SampleBinaryFiles/pyramid_32B.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_1_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST fl;shalgkhsld;akghlkdhg;alkshdg;lkhasdg")
    period: '250'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: modGain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '230'
    minsize: '32'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: isps
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/2
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,1,1,0,1,0,0)
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
    sensitivity: 2*math.pi*freqDeviation/samp_rate
  states: {state: disabled}
- name: digital_hdlc_framer_pb_0
  id: digital_hdlc_framer_pb
  parameters:
    frame_tag_name: Start
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (3 * isamp) / (2 * sens)
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, isamp * isps,isamp / (2 * sens), 300 )
    type: fcc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: freqDeviation * 2
    digital_bandw_ch1: '0'
    gain_dB_ch0: txgain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    comment: 1D53B0399E11FA
    digital_bandw_ch0: (freqDeviation + freqError) * 2
    digital_bandw_ch1: '0'
    gain_dB_ch0: txgain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    label: Input
    type: string
    value: Send
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    color1: red
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:4,0,1,1
    label1: Tx Binary
    legend: 'False'
    size: 32*8*2
    srate: baud
    stemplot: 'True'
    type: float
    update_time: 1/30
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@2:3,0,1,1
    label1: Tx Binary
    label2: ''
    marker1: '8'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@0:3,0,1,1
    label1: Tx Binary
    label2: ''
    marker1: '8'
    size: 1024 * 2
    srate: samp_rate/2
    stemplot: 'True'
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@1:5,0,1,1
    label1: Tx Binary
    label2: ''
    label3: ''
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 10,0,1,1
    label0: Tx
    label1: FSK Mod
    num_tabs: '2'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_source_x_0, '0', digital_gfsk_mod_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_float_to_complex_1_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_delay_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_1_0_0_1_0, '0']
- [blocks_char_to_float_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_char_to_float_1, '0', blocks_repeat_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_float_to_complex_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1_0_0_1_0, '1']
- [blocks_multiply_xx_0_1, '0', blocks_float_to_complex_1_0_0, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', qtgui_time_sink_x_0_1_0_0_1_0, '2']
- [blocks_random_pdu_0, pdus, digital_hdlc_framer_pb_0, in]
- [blocks_repeat_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gfsk_mod_0, '0', limesdr_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_random_pdu_0, generate]

metadata:
  file_format: 1
