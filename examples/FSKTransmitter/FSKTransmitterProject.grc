options:
  parameters:
    author: austin
    generate_options: qt_gui
    id: FSKTransmitter
    output_language: python
    title: FSK Transmitter
  states: {}

blocks:
- name: baudRate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: carrierFrequency
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: fileName
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Transmit
    label0: All 1s
    label1: All 0s
    label2: 50% Duty
    label3: In/Decressing
    label4: Random
    num_opts: '5'
    option0: '"1s_32B.bin"'
    option1: '"0s_32B.bin"'
    option2: '"50p_duty_32B.bin"'
    option3: '"pyramid_32B.bin"'
    option4: '"random_32B.bin"'
    type: string
    value: '"random_32B.bin"'
  states: {}
- name: frequencyDeviation
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: frequencyError
  id: variable
  parameters:
    value: '100'
  states: {}
- name: invertBits
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    gui_hint: 1,1,1,1
    label: Invert Bits
    'true': '-1'
    type: int
    value: '1'
  states: {}
- name: manualMode
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    gui_hint: 2,0,1,1
    label: Manual Mode
    'true': '0'
    type: int
    value: '1'
  states: {}
- name: manualModulation
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,3
    label: ' '
    orient: Qt.Horizontal
    start: '-1'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: radioGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,4
    label: Radio Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '60'
    value: '0'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: baudRate * samplesPerSymbol
  states: {}
- name: samplesPerSymbol
  id: variable
  parameters:
    value: int(32*4)
  states: {}
- name: testFiles
  id: variable
  parameters:
    value: '"/home/austin/Desktop/ground_station/examples/SampleBinaryFiles/"'
  states: {}
- name: binDisplay
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    color1: red
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@1:4,0,1,1
    label1: Tx Binary
    legend: 'False'
    name: '"Binary Transmittion"'
    size: 32*8*2
    srate: baudRate
    stemplot: 'True'
    type: float
    update_time: 1/30
    ylabel: ''
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: manualMode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: charToFloat
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: convertToBinary
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: fileSource
  id: blocks_file_source
  parameters:
    file: testFiles + fileName
    repeat: 'True'
    type: byte
  states: {}
- name: frequencyModulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2* math.pi * (baudRate / sampleRate)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, os
  states: {}
- name: iqOutput
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: iqTimeOutput
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@0:3,0,1,1
    label1: Tx Binary
    label2: ''
    marker1: '8'
    size: 1024 * 2
    srate: sampleRate
    stemplot: 'True'
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    comment: 1D53B0399E11FA
    digital_bandw_ch0: (frequencyDeviation + frequencyError) * 2
    digital_bandw_ch1: '0'
    gain_dB_ch0: radioGain
    gain_dB_ch1: '0'
    oversample: '0'
    rf_freq: carrierFrequency
    samp_rate: sampleRate
  states: {state: disabled}
- name: manualSource
  id: analog_const_source_x
  parameters:
    const: manualModulation
    type: float
  states: {}
- name: repeatToSymbolLength
  id: blocks_repeat
  parameters:
    interp: samplesPerSymbol
    type: float
  states: {}
- name: shiftTransform
  id: blocks_add_const_vxx
  parameters:
    const: '-1 * invertBits'
    type: float
  states: {}
- name: stretchTransform
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * invertBits
    type: float
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 10,0,1,4
    label0: Tx
    label1: FSK Mod
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: sampleRate
    center_freq0: carrierFrequency
    dev_args: '""'
    gain0: radioGain
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: sampleRate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_selector_0, '0', frequencyModulator, '0']
- [charToFloat, '0', binDisplay, '0']
- [charToFloat, '0', stretchTransform, '0']
- [convertToBinary, '0', charToFloat, '0']
- [fileSource, '0', convertToBinary, '0']
- [frequencyModulator, '0', iqOutput, '0']
- [frequencyModulator, '0', iqTimeOutput, '0']
- [frequencyModulator, '0', limesdr_sink_0_0, '0']
- [frequencyModulator, '0', uhd_usrp_sink_0, '0']
- [manualSource, '0', blocks_selector_0, '0']
- [repeatToSymbolLength, '0', blocks_selector_0, '1']
- [shiftTransform, '0', repeatToSymbolLength, '0']
- [stretchTransform, '0', shiftTransform, '0']

metadata:
  file_format: 1
